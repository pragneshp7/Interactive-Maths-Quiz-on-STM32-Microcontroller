# Keil uVision project Keyboard.uvprojx, settings and files
target Debug (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Keyboard
  c flags: Optim=2
  c define: HSE_VALUE=25000000 GLCD_MIRROR_Y = 0, GLCD_SWAP_XY = 0
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source
    ./: main.c Keyboard.c stdout_display.c tm_stm32f4_rng.c tm_stm32f4_rng.h
  group Documentation
    ./: Abstract.txt
target Release (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: as above
  output: Keyboard
  c flags: Optim=4
  c define: HSE_VALUE=25000000 GLCD_MIRROR_Y = 0, GLCD_SWAP_XY = 0
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 5.1.2, CMSIS:RTOS:Keil RTX5 5.4.0, CMSIS:RTOS2:Keil RTX5 5.4.0, Compiler:Event Recorder 1.4.0, Compiler:I/O:File 1.2.0, Compiler:I/O:STDOUT 1.2.0, Board Support:Graphic LCD 2.0.0, File System:CORE 6.11.0, File System:Drive:NAND 6.11.0, USB:CORE 6.13.0, USB:CORE 6.13.0, USB:Host 6.13.0, USB:Host:HID 6.13.0, CMSIS Driver:NAND:Memory Bus 1.1.0, CMSIS Driver:USB Host:Full-speed 2.18, CMSIS Driver:USB Host:High-speed 2.19, Device:STM32Cube Framework:Classic 1.5.0, Device:STM32Cube HAL:ADC 1.5.0, Device:STM32Cube HAL:Common 1.5.0, Device:STM32Cube HAL:Cortex 1.5.0, Device:STM32Cube HAL:DMA 1.5.0, Device:STM32Cube HAL:GPIO 1.5.0, Device:STM32Cube HAL:PWR 1.5.0, Device:STM32Cube HAL:RCC 1.5.0, Device:STM32Cube HAL:SRAM 1.5.0, Device:Startup 2.5.0
